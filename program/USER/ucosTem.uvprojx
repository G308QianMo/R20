# Keil uVision project ucosTem.uvprojx, settings and files
target Robocon2020 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HEADER;..\UCOSIII_3_04\uC-CPU;..\UCOSIII_3_04\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII_3_04\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII_3_04\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\UCOSIII_3_04\uC-CPU;..\UCOSIII_3_04\uC-LIB;..\UCOSIII_3_04\uCos_BSP;..\UCOSIII_3_04\uCos_Config;..\UCOSIII_3_04\uCOS-III;..\UCOSIII_3_04\uCOS-III\Source;..\UCOSIII_3_04\uCOS-APP;..\ALGORITHM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
  group HEADER
    ../HEADER/: include.h readme.txt init.h actuator_control.h basial_move.h protocol.h sensor.h interrupt.h mission.h vect.h gyro.h elmo.h math.h my_math.h pid_control.h pid_parameter.h stdint.h
  group INIT
    ../INIT/: init.c readme.txt
  group INTERRUPT
    ../INTERRUPT/: interrupt.c readme.txt
  group PROTOCOL
    ../PROTOCOL/: protocol.c readme.txt elmo.c
  group SENSOR
    ../SENSOR/: sensor.c readme.txt gyro.c
  group ACTUATOR_CONTRL
    ../ACTUATOR_CONTRL/: actuator_control.c readme.txt
  group BASIAL_MOVE
    ../BASIAL_MOVE/: basial_move.c readme.txt
  group MISSION
    ../MISSION/: mission.c readme.txt
  group UCOS_BSP
    ../UCOSIII_3_04/uCos_BSP/: bsp.c
  group UCOS_CONFIG
    ../UCOSIII_3_04/uCos_Config/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOS_CPU
    ../UCOSIII_3_04/uC-CPU/: cpu_core.c
    ../UCOSIII_3_04/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOS_CORE
    ../UCOSIII_3_04/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS_LIB
    ../UCOSIII_3_04/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII_3_04/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOS_PORT
    ../UCOSIII_3_04/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS_APP
    ../UCOSIII_3_04/uCOS-APP/: ucos_app.c ucos_init.c readme.txt
  group ALGORITHM
    ../ALGORITHM/: pid_control.c pid_parameter.c
